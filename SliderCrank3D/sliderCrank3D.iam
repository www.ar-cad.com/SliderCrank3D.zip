# Autodesk Inventor assembly: sliderCrank3D
## iProperties
Created: 2009-04
Part Number: sliderCrank3D
Document SubType Name: Assembly
Designer: Lochan
Author: Lochan
